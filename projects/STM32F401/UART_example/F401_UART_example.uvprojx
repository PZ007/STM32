# Keil uVision project F401_UART_example.uvprojx, settings and files
target Debug (ARM-ADS)
  device: STM32F401RE STMicroelectronics
  cpu: IROM(0x08000000,0x60000) IRAM(0x20000000,0x18000) CPUTYPE("Cortex-M4") FPU2 CLOCK(84000000) ELITTLE
  output: F401_UART_example
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: STM32F401xE,USE_STDPERIPH_DRIVER,__USE_C99_MATH,__DEBUG
  c include: .;..\..\..\config\shared;..\..\..\config\STM32F401;..\..\..\drivers\STM32F401
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group src
    ./: init.c main.c retarget.c
  group cfg
    ../../../config/shared/: cfgGlobal.h
    ../../../config/STM32F401/: cfgPlatform.c
    ./: cfgProject.c
  group drv
    ../../../drivers/STM32F401/: drvGPIO.c drvSysTick.c drvUART.c
  group prp
    ./: prpLine.c
  group ::Device
    C:/Keil/ARM/PACK/Keil/STM32F4xx_DFP/1.0.7/Device/StdPeriph_Driver/src/: misc.c stm32f4xx_rcc.c
    RTE/Device/STM32F401RE/: RTE_Device.h startup_stm32f401xx.s stm32f4xx_conf.h system_stm32f4xx.c
software components: CMSIS:CORE 3.20.0, Device:Startup 1.3.1, Device:StdPeriph Drivers:Framework 1.3.1, Device:StdPeriph Drivers:RCC 1.3.0
